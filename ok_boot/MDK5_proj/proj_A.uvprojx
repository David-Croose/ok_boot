# Keil uVision project proj_A.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: proj_A
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD  USE_STDPERIPH_DRIVER
  c include: ..\1_level;..\1_level\public;..\2_level\boot;..\3_level\bsp;..\3_level\cm3\core;..\3_level\cm3\stm32f10x;..\3_level\cm3\stm32f10x\std_fwlib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group 1
    ../1_level/: main.c
    ../1_level/public/: clib.c crc.c delay.c def.h
  group 2/boot
    ../2_level/boot/: boot.c
  group 3/bsp
    ../3_level/bsp/: usart1.c stmflash.c
  group 3/cm3/core
    ../3_level/cm3/core/: core_cm3.c
  group 3/cm3/stm32f10x
    ../3_level/cm3/stm32f10x/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group 3/cm3/stm32f10x/std_fwlib
    ../3_level/cm3/stm32f10x/std_fwlib/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
